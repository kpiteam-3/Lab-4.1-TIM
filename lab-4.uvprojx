# Keil uVision project lab-4.uvprojx, settings and files
target TIM Timers (ARM-ADS)
  device: STM32F103C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab-4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Source Group 1
    ./: main.c delay.h TIMER.h
software components: Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
